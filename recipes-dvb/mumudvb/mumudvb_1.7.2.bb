include mumudvb.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b \
                   "

S = "${WORKDIR}/MuMuDVB-${PV}"

SRC_URI[md5sum] = "fc01a56c4a3f84861c55f96f9a13429a"
SRC_URI[sha256sum] = "76a9810b0f0d5c3323792288956790be93f89f492bb373de14d3642c008901ea"

